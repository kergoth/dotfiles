python do_fetch () {
    raise SystemExit(1)
}
