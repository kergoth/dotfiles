## openembedded/conf/layer.conf
```bitbake
BBPATH .= ":${LAYERDIR}"

BBFILE_COLLECTIONS += ".oe"
BBFILE_PRIORITY_.oe = "40"
BBFILE_PATTERN_.oe = "^$"
```
